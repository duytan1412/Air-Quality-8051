# Keil uVision project Smart Room.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Smart Room +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./drivers/: ads1115.c aht10.c delay.c gp2y1014.c mq2.c lcd.c i2c.c
    ./core/: uart.c display.c uart_protocol.c utils.c watchdog.c
